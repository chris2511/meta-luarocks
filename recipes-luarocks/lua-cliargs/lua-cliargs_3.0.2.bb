SUMMARY = "A command-line argument parser."
DESCRIPTION = "This module adds support for accepting CLI arguments easily using multiple notations and argument types. cliargs allows you to define required, optional, and flag arguments."
HOMEPAGE = "https://github.com/amireh/lua_cliargs"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=e258701153972a6cb73ba10eb984c8b6"

SRC_URI = "git://github.com/amireh/lua_cliargs.git;branch=master;protocol=https"
SRCREV = "5e77d9e2295abd3a67af509090ac7b430f4ad266"

inherit luarocks
