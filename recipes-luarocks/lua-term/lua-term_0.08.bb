DESCRIPTION = "Terminal functions for Lua"
HOMEPAGE = "https://github.com/hoelzro/lua-term"
LICENSE = "MIT&X11"
LIC_FILES_CHKSUM = "file://COPYING;md5=99dd4648f9c5df2787ede8ba761a278e"

SRC_URI = "git://github.com/hoelzro/lua-term.git;branch=master;protocol=https"
SRCREV = "36ec4e5dd6bf7a485fbab72f0c0940aaa60badfb"

inherit luarocks
